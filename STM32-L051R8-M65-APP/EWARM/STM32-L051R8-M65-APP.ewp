# IAR project STM32-L051R8-M65-APP.ewp, settings and files
configuration STM32-L051R8-M65-APP (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051R8 ST STM32L051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx; _iar; STM32_L051R8; _2G; GSM2G; ACCELOMETER; DEBUG
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\..\RawLibraries; ..\..\ApplicationLayer; ..\..\RawLibraries\PahoMqtt
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32-L051R8-M65-APP.hex
  ILINK.IlinkOutputFile: STM32-L051R8-M65-APP.out
  ILINK.IlinkIcfFile: stm32l051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l051xx.s
  group Application/User/Core
    ../Core/Src/: adc.c dma.c gpio.c i2c.c iwdg.c main.c rtc.c stm32l0xx_hal_msp.c stm32l0xx_it.c tim.c usart.c
  group Application/User/Inc
    ../Core/Inc/: adc.h dma.h gpio.h i2c.h iwdg.h main.h rtc.h stm32l0xx_hal_conf.h stm32l0xx_it.h tim.h usart.h
  group ApplicationLayer
    ../../ApplicationLayer/: usr_general.h usr_nvs.c usr_nvs.h usr_process.c usr_process.h usr_sensor.c usr_sensor.h usr_sleep.c usr_sleep.h usr_system.c usr_system.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group RawLibraries
    ../../RawLibraries/: usr_arch.h usr_lib_accel.c usr_lib_accel.h usr_lib_adc.c usr_lib_adc.h usr_lib_battery.c usr_lib_battery.h usr_lib_gsm.c usr_lib_gsm.h usr_lib_halleffect.c usr_lib_halleffect.h usr_lib_led.c usr_lib_led.h usr_lib_log.c usr_lib_log.h usr_lib_ntc.c usr_lib_ntc.h usr_lib_rtc.c usr_lib_rtc.h usr_lib_sensor.c usr_lib_sensor.h
  group RawLibraries/PahoMqtt
    ../../RawLibraries/PahoMqtt/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
