<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32-L051R8-M65-APP.ewp</path>
  </project>
  <batchBuild />
</workspace>
