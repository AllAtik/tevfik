# IAR project STM32-L051R8-M65-BOOT.ewp, settings and files
configuration STM32-L051R8-M65-BOOT (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051R8 ST STM32L051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx; STM32_L051R8_M65_BOOT
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\..\RawLibraries; ..\..\BootApplicationLayer
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32-L051R8-M65-BOOT.hex
  ILINK.IlinkOutputFile: STM32-L051R8-M65-BOOT.out
  ILINK.IlinkIcfFile: stm32l051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l051xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c usart.c rtc.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Application/User/Inc
    ../Core/Inc/: gpio.h main.h stm32l0xx_hal_conf.h stm32l0xx_it.h usart.h
  group BootApplicationLayer
    ../../BootApplicationLayer/: usr_general.h usr_system.c usr_system.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group RawLibraries
    ../../RawLibraries/: usr_accel_lib.c usr_accel_lib.h usr_adc_lib.c usr_adc_lib.h usr_arch.h usr_battery_lib.c usr_battery_lib.h usr_gsm_lib.c usr_gsm_lib.h usr_halleffect_lib.c usr_halleffect_lib.h usr_led_lib.c usr_led_lib.h usr_ntc_lib.c usr_ntc_lib.h usr_rtc_lib.c usr_rtc_lib.h usr_sensor_lib.c usr_sensor_lib.h
