<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32-L051R8-M66-BOOT.ewp</path>
  </project>
  <batchBuild />
</workspace>
